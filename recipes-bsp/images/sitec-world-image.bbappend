require recipes-bsp/images/sitec-s4.inc