FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

PR = "r1"

SRC_URI += "file://gpsd-default"
