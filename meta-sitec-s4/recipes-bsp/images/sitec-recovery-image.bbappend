IMAGE_INSTALL += "srecovery"