FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"

PR = "r1"
