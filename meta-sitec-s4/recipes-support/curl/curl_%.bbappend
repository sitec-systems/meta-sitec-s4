PR = "r1"

PACKAGECONFIG_append_pn-curl = " smtp"
